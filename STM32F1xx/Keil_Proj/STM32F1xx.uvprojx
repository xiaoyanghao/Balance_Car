# Keil uVision project STM32F1xx.uvprojx, settings and files
target ProjectApp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1xx
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c include: ..\onboard\UserApps\Driver\Cmsis\cmsis;..\onboard\UserApps\Driver\Cmsis\cmsis_boot;..\onboard\UserApps\Driver\Cmsis\cmsis_lib\include;..\onboard\UserApps\Driver\PeriphLayer;..\onboard\UserApps\Driver\PlatAbsLayer;..\onboard\UserApps\Ethernet;..\onboard\UserApps\Share
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Periphlayer
    ../onboard/UserApps/Driver/PeriphLayer/: periph_serial_adc.c periph_serial_adc.h periph_serial_can.c periph_serial_can.h periph_serial_port.c periph_serial_port.h periph_serial_pwm.c periph_serial_pwm.h periph_serial_w5500.c periph_serial_w5500.h
  group PlatAbslayer
    ../onboard/UserApps/Driver/PlatAbsLayer/: bsp_adc_drv.c bsp_adc_drv.h bsp_can_drv.c bsp_can_drv.h bsp_gpio_drv.c bsp_gpio_drv.h bsp_rcc_drv.c bsp_rcc_drv.h bsp_spi_drv.c bsp_spi_drv.h bsp_timer_drv.c bsp_timer_drv.h bsp_uart_drv.c bsp_uart_drv.h
  group Stm32f1_Lib
    ../onboard/UserApps/Driver/Cmsis/cmsis_boot/startup_keil/: startup_stm32f105xc.s
    ../onboard/UserApps/Driver/Cmsis/cmsis_boot/: stm32f1xx.h stm32f1xx_hal_conf.h stm32f1xx_it.c stm32f1xx_it.h stm32f105xc.h system_stm32f1xx.c system_stm32f1xx.h
    ../onboard/UserApps/Driver/Cmsis/cmsis_lib/source/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
    ../onboard/UserApps/Driver/Cmsis/cmsis_lib/include/: stm32_hal_legacy.h stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_spi.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h
  group Ethernet
    ../onboard/UserApps/Ethernet/: ethrnet.c ethrnet.h socket.c socket.h
  group Share
    ../onboard/UserApps/Share/: share_math.c share_math.h
  group Startup
    ../onboard/UserApps/Startup/: main.c
