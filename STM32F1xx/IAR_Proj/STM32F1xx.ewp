# IAR project STM32F1xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105R8 ST STM32F105R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F105xC; MOTION_DRIVER_TARGET_MSP430; MPU9150
  ICCARM.CCIncludePath2: ..\onboard\UserApps\Driver\Cmsis\cmsis; ..\onboard\UserApps\Driver\Cmsis\cmsis_boot; ..\onboard\UserApps\Driver\Cmsis\cmsis_lib\include; ..\onboard\UserApps\Driver\PlatAbsLayer; ..\onboard\UserApps\Driver\PeriphLayer; ..\onboard\UserApps\Share; ..\onboard\UserApps\Ethernet; ..\onboard\UserApps\Sensor\SensorRaw; ..\onboard\UserApps\Sensor\FCEstimation; ..\onboard\UserApps\Device; ..\onboard\UserApps\Interface; ..\onboard\UserApps\Control
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F105.hex
  ILINK.IlinkOutputFile: STM32F1xx.out
  ILINK.IlinkIcfFile: stm32f105xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ProjectApp/Control
    ../onboard/UserApps/Control/: control.c control.h
  group ProjectApp/Device
    ../onboard/UserApps/Device/: txg_eeprom.c txg_eeprom.h
  group ProjectApp/Driver/Periphlayer
    ../onboard/UserApps/Driver/PeriphLayer/: periph_at24c512b.c periph_at24c512b.h periph_mpu60x0.c periph_mpu60x0.h periph_serial_adc.c periph_serial_adc.h periph_serial_can.c periph_serial_can.h periph_serial_motor.c periph_serial_motor.h periph_serial_port.c periph_serial_port.h periph_serial_w5500.c periph_serial_w5500.h
  group ProjectApp/Driver/PlatAbslayer
    ../onboard/UserApps/Driver/PlatAbsLayer/: bsp_adc_drv.c bsp_adc_drv.h bsp_can_drv.c bsp_can_drv.h bsp_delay_drv.c bsp_delay_drv.h bsp_gpio_drv.c bsp_gpio_drv.h bsp_i2c_drv.c bsp_i2c_drv.h bsp_rcc_drv.c bsp_rcc_drv.h bsp_spi_drv.c bsp_spi_drv.h bsp_timer_drv.c bsp_timer_drv.h bsp_uart_drv.c bsp_uart_drv.h
  group ProjectApp/Driver/Stm32f1_lib
    ../onboard/UserApps/Driver/Cmsis/cmsis_boot/startup/: startup_stm32f105xc.s
    ../onboard/UserApps/Driver/Cmsis/cmsis_lib/include/: stm32_hal_legacy.h stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_spi.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h
    ../onboard/UserApps/Driver/Cmsis/cmsis_boot/: stm32f1xx.h stm32f1xx_hal_conf.h stm32f1xx_it.c stm32f1xx_it.h system_stm32f1xx.c system_stm32f1xx.h
    ../onboard/UserApps/Driver/Cmsis/cmsis_lib/source/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group ProjectApp/Ethernet
    ../onboard/UserApps/Ethernet/: ethrnet.c ethrnet.h socket.c socket.h
  group ProjectApp/Interface
    ../onboard/UserApps/Interface/: net_link.c net_link.h
  group ProjectApp/Sensor/FCEstimation
    ../onboard/UserApps/Sensor/FCEstimation/: txg_ahrs_fusion.c txg_ahrs_fusion.h
  group ProjectApp/Sensor/SensorRaw
    ../onboard/UserApps/Sensor/SensorRaw/: imu.c imu.h
  group ProjectApp/Share
    ../onboard/UserApps/Share/: shared.h txg_low_pass_filter.c txg_low_pass_filter.h txg_math.c txg_math.h txg_matrix3.c txg_matrix3.h txg_vector3.c txg_vector3.h
  group ProjectApp/Startup
    ../onboard/UserApps/Startup/: main.c
